# IAR project RTOSDemo.ewp, settings and files
configuration YRPBRL78G13 (RL78, debug)
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 130
  General.GenNearHeapSize: 0
  General.GenFarHeapSize: 0
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: YRPBRL78G13
  ICCRL78.CCDiagSuppress: Pa082
  ICCRL78.CCIncludePath2: ..\..\Source\include; ..\Common\include; $PROJ_DIR$; ..\..\Source\portable\IAR\RL78
  ARL78.AsmIncludePath: ..\..\Source\portable\IAR\RL78; $PROJ_DIR$
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkr5f100le.xcl
  XLINK.XlinkStackSize: 1
configuration YRDKRL78G14 (RL78, debug)
  as the first configuration, except:
  General.GenDeviceSelect: R5F104PJ RL78 - R5F104PJ
  General.GenCodeModel: 1
  General.GenDataModel: 1
  ICCRL78.CCDefines: YRDKRL78G14
  ICCRL78.CCDiagSuppress: Pa082, PE1053
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkr5f104pj.xcl
configuration RSKRL78G1C (RL78, debug)
  as the first configuration, except:
  General.GenDeviceSelect: R5F10JGC RL78 - R5F10JGC
  General.GenCodeModel: 1
  General.GenDataModel: 1
  ICCRL78.CCDefines: RSKRL78G1C
  ICCRL78.CCDiagSuppress: Pa082, Pe1053
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkr5f10jgc.xcl
configuration RSKRL78L13 (RL78, debug)
  as the first configuration, except:
  General.GenDeviceSelect: R5F10WMG RL78 - R5F10WMG
  General.GenCodeModel: 1
  General.GenDataModel: 1
  ICCRL78.CCDefines: RSKRL78L13
  ICCRL78.CCDiagSuppress: Pa082, Pe1053
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkr5f10wmg.xcl
configuration RL78_G1A_TB (RL78, debug)
  as the first configuration, except:
  General.GenDeviceSelect: R5F10ELE RL78 - R5F10ELE
  General.GenCodeModel: 1
  General.GenDataModel: 1
  ICCRL78.CCDefines: RL78_G1A_TB
  ICCRL78.CCDiagSuppress: Pa082, Pe1053
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkr5f10wmg.xcl
configuration RSKRL78L1C (RL78, debug)
  as the first configuration, except:
  General.GenDeviceSelect: R5F110PJ RL78 - R5F110PJ
  General.GenCodeModel: 1
  General.GenDataModel: 1
  ICCRL78.CCDefines: RSKRL78L1C
  ICCRL78.CCDiagSuppress: Pa082, Pe1053
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkr5f110pj.xcl
  group Demo Source
    ./: ExampleISR.s87 main.c main_blinky.c main_full.c RegTest.s87
  group Demo Source/StandardDemos
    ../Common/Minimal/: blocktim.c dynamic.c PollQ.c
  group Kernel Source
    ../../Source/portable/MemMang/: heap_1.c
    ../../Source/: list.c queue.c tasks.c timers.c
    ../../Source/portable/IAR/RL78/: port.c portasm.s87
