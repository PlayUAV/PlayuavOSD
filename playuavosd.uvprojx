# Keil uVision project playuavosd.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: playuavosd
  AfterMake: fromelf.exe --bin --output ./bin/playuavosd.bin ./Objects/playuavosd.axf
  c flags: Optim=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000,ARM_MATH_CM4, __FPU_PRESENT = 1,__FPU_USED =1, __CC_ARM
  c include: .\Library\CMSIS\Include;.\Library\CMSIS\STM32F4xx\Include;.\Library\STM32F4xx\STM32F4xx_StdPeriph_Driver\inc;.\Library\FreeRTOS8.1.2;.\Library\FreeRTOS8.1.2\Source\include;.\Library\FreeRTOS8.1.2\Source\portable\RVDS\ARM_CM4F;.\Library\mavlink\v1.0;.\Library\msheap;.\app;.\Drivers;.\Library\CMSIS\DSP_Lib\Examples\Common\Include;.\Library\STM32F4xx\usb_cdc_device
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./app/: main.c stm32f4xx_it.c osdcore.c graphengine.c fonts.c board.h system_stm32f4xx.c board.c osdproc.c font_outlined8x14.c font_outlined8x8.c osdmavlink.c m3dlib.c max7456.c math3d.c DJICanDecoder.c osdconfig.c stm32f4xx_conf.h osdvar.c m2dlib.c UAVObj.c uavTalk.c
    ./Library/CMSIS/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group FreeRTOS8.1.2
    ./Library/FreeRTOS8.1.2/: FreeRTOSConfig.h
    ./Library/FreeRTOS8.1.2/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./Library/FreeRTOS8.1.2/Source/portable/RVDS/ARM_CM4F/: port.c
    ./Library/FreeRTOS8.1.2/Source/portable/MemMang/: heap_2.c
  group STM32F4xx_StdPeriph_Driver
    ./Library/STM32F4xx/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_flash.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group Drivers
    ./Drivers/: spi.c tm_stm32f4_usb_vcp.c led.c usart2.c
  group msheap
    ./Library/msheap/: msheap.c pios_msheap.c
  group DSP_Lib
    ./Library/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ./Library/CMSIS/DSP_Lib/Examples/Common/Source/: math_helper.c
  group USB CDC Device
    ./Library/STM32F4xx/usb_cdc_device/: usb_bsp.c usb_bsp.h usb_conf.h usb_core.c usb_core.h usb_dcd.c usb_dcd.h usb_dcd_int.c usb_dcd_int.h usb_defines.h usb_regs.h usbd_cdc_core.c usbd_cdc_core.h usbd_cdc_vcp.c usbd_cdc_vcp.h usbd_conf.h usbd_core.c usbd_core.h usbd_def.h usbd_desc.c usbd_desc.h usbd_ioreq.c usbd_ioreq.h usbd_req.c usbd_req.h usbd_usr.c usbd_usr.h
